# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\ESP8266;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\motor;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\tft;..\SYSTEM\usart2;..\HARDWARE\RFID;..\HARDWARE\SERVER;..\HARDWARE\EXTI;..\HARDWARE\flash;..\HARDWARE\KEY1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/tft/: tft.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/SERVER/: server.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/KEY1/: key1.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart2/: usart2.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c
  group README
    ../: README.TXT
